# Keil uVision project twr_init.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.14.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: twr_init +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NRF_LOG_USES_RTT=1 BOARD_PCA10040=1 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET NRF_LOG_USES_UART=1 NRF52 SWI_DISABLE0
  c include: config;..\..\external\segger_rtt;..\..\external\freertos\config;..\..\external\freertos\portable\ARM\nrf52;..\..\external\freertos\portable\CMSIS\nrf52;..\..\external\freertos\source\include;..\..\components\libraries\fifo;..\..\deca_driver;..\..\config\spi_pca10040;..\..\config;..\..\components\drivers_nrf\common;..\..\components\drivers_nrf\delay;..\..\components\drivers_nrf\gpiote;..\..\components\drivers_nrf\clock;..\..\components\drivers_nrf\hal;..\..\components\drivers_nrf\nrf_soc_nosd;..\..\components\drivers_nrf\spi_master;..\..\components\drivers_nrf\uart;..\..\components\libraries\button;..\..\components\libraries\timer;..\..\components\libraries\uart;..\..\components\libraries\util;..\..\components\toolchain;..\bsp;..\..\deca_driver\port;..\..\components\boards
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ./: main.c ss_init_main.c sys_config.h
  group nRF_Drivers
    ../../components/drivers_nrf/delay/: nrf_delay.c
    ../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ../../components/drivers_nrf/clock/: nrf_drv_clock.c
  group nRF_Libraries
    ../../components/libraries/util/: app_util_platform.c app_error.c app_error_weak.c nrf_assert.c nrf_log.c
  group DW1000
    ../../deca_driver/: deca_device.c deca_params_init.c
    ../../deca_driver/port/: port_platform.c port_platform.h
  group Config
    ./config/: nrf_drv_config.h nrf_drv_config_validation.h
    ../../external/freertos/config/: FreeRTOSConfig.h
  group nRF_Segger_RTT
    ../../external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group freeRTOS
    ../../components/libraries/timer/: app_timer_freertos.c
    ../../external/freertos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../external/freertos/source/portable/MemMang/: heap_1.c
    ../../external/freertos/portable/CMSIS/nrf52/: port_cmsis.c port_cmsis_systick.c portmacro_cmsis.h
    ../../external/freertos/portable/ARM/nrf52/: port.c
software components: CMSIS:CORE 5.0.1, Device:Startup 8.14.1, Device:StartupConfig 8.14.1
